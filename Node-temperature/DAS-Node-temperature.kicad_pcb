# Repository NicheHardware/DAS-layout

File README.md:

<div>
	<div align="center">
		
	</div>
	<div align="center">
		
	</div>
</div>

**DAS** is a Low-power Distributed Acquisition System. This is the repo of the layout of this system.

- DAS Layout: https://github.com/NicheHardware/DAS-layout
- DAS Console: https://github.com/NicheHardware/DAS-app
- DAS Firmware(Private): https://github.com/NicheHardware/DAS-Firmware

```mermaid
flowchart LR
	n1@{ shape: "hex", label: "Scanner" }
	n2@{ shape: "circle", label: "Node" }
	n3@{ shape: "circle", label: "Node" }
	n4@{ shape: "circle", label: "Node" }
	n5@{ label: "PC" }
	n6@{ shape: "circle", label: "Node" }
	
	n2 -.-|"temperature"| n1
	n3 -.-|"temperature"| n1
	n4 -.-|"voltage"| n1
	n6 -.-|"power"| n1
	n1 ---|"HID"| n5
```
## System Architecture
Node collects data through various sensors and then broadcasts the collected data through BLE.  
Scanner acquires data from each node by scanning the BLE broadcast.  
In the same scenario, multiple Scanners can acquire all the data, and increasing the number of Scanners will not increase the bandwidth consumption.  
For low-frequency data acquisition, each Node will only consume a very small amount of bandwidth, which allows a very large number of Nodes to acquire data at the same time.  
If there is a special need, the Nodes can form a network to realize a large area coverage.  

节点通过各种传感器采集数据，然后通过 BLE 广播采集到的数据。  
Scanner 通过扫描 BLE 广播获取各个节点的数据。  
同一个场景下，多个 Scanner 都可以获取到所有的数据，并且增加 Scanner 的数量不会增加带宽消耗。  
对于低频采集的数据，每个 Node 只会消耗非常小的带宽，这样可以允许非常多的 Node 同时进行数据采集。  
如果有特殊需要，可以让 Node 组成网络实现大面积的覆盖。

## KiCad design Node-temperature/DAS-Node-temperature.kicad_pcb

Parts:
BT1: Battery_Cell; BATT_Handsolder
C1: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C2: 0.47uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C3: 2.2uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C4: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 10uF/16V; C_0603_1608Metric
C6: 1uF/16V; C_0402_1005Metric
C7: 4.7uF; C_0402_1005Metric
C8: 1.0uF; C_0402_1005Metric
C9, C10: 100pF; C_0603_1608Metric
D1, D2, D3, D4, D5: LED White; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6: LED Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: M2 hole; MountingHole_2.2mm_M2_DIN965
J1: ANT; Texas_SWRA117D_2.4GHz_Left
J4: NTC 3950 100k; PinHeader_1x02_P2.00mm_Vertical
J5: Conn_01x02; PinHeader_1x02_P1.27mm_Vertical
L1: 10uH; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
P1: USB_C_Plug_USB2.0; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R1, R2, R3, R4, R5: 100R; R_0402_1005Metric_Pad0.72x0.64mm
R6: 1k; R_0402_1005Metric
R7: 10k; R_0402_1005Metric
R8, R9: 5.1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22: 5.1k; R_0402_1005Metric_Pad0.72x0.64mm
SW1: SW_POWER; SK-3296S-01-L1
TP1: GND; TestPoint_Pad_D1.5mm
TP2: PB7; TestPoint_Pad_D1.5mm
TP3: PB23; TestPoint_Pad_D1.5mm
U1: CH584F; QFN-32-1EP_4x4mm_P0.4mm_EP2.65x2.65mm_ThermalVias
U2: ME4064AM5G; SOT-23-5
U3: ME6210A33M3G; TSOT-23
Y2: 8DSC320G0008L; Oscillator_SMD_EuroQuartz_XO32-4Pin_3.2x2.5mm
mark1, mark2, mark3, mark4: Fiducial; marker1

Connections:
+3V3: C4.1, C7.1, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), J4.1, R11.2, U1.4 (VIO33), U3.2 (VOUT)
+4V: BT1.1 (+), SW1.2 (B), U2.3 (BAT)
+5V: C8.1, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), R6.1, U2.4 (VCC)
/ADC1+: C10.2, J4.2, R19.1, U1.26 (PA4/A0)
/ADC1-: C9.2, R14.1, R15.1, U1.31 (PA12/A2)
/ADC2+: U1.27 (PA5/A1)
/ADC2-: U1.30 (PA13/A3)
/BOOT: J5.2, U1.20 (PB22)
/LED1: R1.2, U1.9 (PB15)
/LED2: R2.2, U1.8 (PB16/NFC-)
/LED3: R3.2, U1.7 (PB17/NFC+)
/LED4: R4.2, U1.6 (PB8\NFCM)
/LED5: R5.2, U1.5 (PB9/NFCI)
/PB7: TP2.1, U1.15 (PB7)
/PB23: TP3.1, U1.19 (PB23)
/PROGD+: P1.A6 (D+), U1.13 (UD+)
/PROGD-: P1.A7 (D-), U1.14 (UD-)
/VDCIA: C1.2, C3.1, L1.2, U1.2 (VDCID), U1.25 (VDCIA)
/VSW: L1.1, U1.3 (VSW)
GND: BT1.2 (-), C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.1, J1.2, J5.1, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), R7.2, R8.2, R9.2, R18.2, R22.2, SW1.3 (C), TP1.1, U1.0 (GND), U2.2 (GND), U3.1 (GND), Y2.2, Y2.4
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R3.1
unnamed: D4.1 (K), R4.1
unnamed: D5.1 (K), R5.1
unnamed: D6.2 (A), R6.2
unnamed: D6.1 (K), U2.1 (CHRG#)
unnamed: J1.1, U1.24 (ANT)
unnamed: P1.A5 (CC), R8.1
unnamed: P1.B5 (VCONN), R9.1
unnamed: R11.1, R12.2
unnamed: R12.1, R13.2
unnamed: R13.1, R14.2
unnamed: R15.2, R16.1
unnamed: R16.2, R17.1
unnamed: R17.2, R18.1
unnamed: R19.2, R20.1
unnamed: R20.2, R21.1
unnamed: R21.2, R22.1
unnamed: C5.1, C6.1, SW1.1 (A), U3.3 (VIN)
unnamed: C2.2, U1.23 (VINTA)
unnamed: U1.22 (X32MI), Y2.1
unnamed: U1.21 (X32MO), Y2.3
unnamed: R7.1, U2.5 (PROG)

Notes on the sheet:
不使用DCDC时 L1=0R C3=0.1uF C4=0.1uF 使用DCDC时 L1=10uH C3=2.2uF C4=2.2uF

Board: 2 copper layers, 24.4 x 32.6 mm, 59 parts (4 on the bottom side), 42 nets.

## KiCad design Scanner/DAS-Scanner.kicad_pcb

Board: 2 copper layers, 24.0 x 62.8 mm, 33 parts (0 on the bottom side), 32 nets.

Parts:
C1, C2: 0.1uF/2.2uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C3: 0.47uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C4: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 10uF/16V; C_0603_1608Metric
C6: 1uF/16V; C_0402_1005Metric
C7: 4.7uF; C_0402_1005Metric
D1, D2, D3: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: M3 hole; MountingHole_3.2mm_M3_DIN965
J1: TETST_PORT; PinHeader_1x04_P2.54mm_Vertical
J2: ANT; Texas_SWRA117D_2.4GHz_Left
J3: LOG_PORT; PinHeader_1x03_P2.54mm_Vertical
J4: PWR_PORT; PinHeader_1x03_P2.54mm_Vertical
L1: 0R/10uH; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
P1, P2: USB_C_Plug_USB2.0; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R1, R2, R3, R4: 5.1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R5, R6, R7: 100R; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
SW1: SW_Push; EL3625
U1: CH585M; QFN-48_EP_5x5_Pitch0.35mm
U2: ME6210A33M3G; TSOT-23
Y1: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm
Y2: Crystal_GND24_Small; Oscillator_SMD_EuroQuartz_XO32-4Pin_3.2x2.5mm

Connections:
+3V3: C4.1, C7.1, D1.2 (A), D2.2 (A), D3.2 (A), U1.3 (VIO33), U2.2 (VOUT)
+5V: C5.1, C6.1, J4.3, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), P2.A4 (VBUS), P2.A9 (VBUS), P2.B4 (VBUS), P2.B9 (VBUS), U2.3 (VIN)
/BOOT: J4.2, SW1.1, U1.26 (PB22)
/LED1: R7.2, U1.23 (PB1)
/LED2: R6.2, U1.22 (PB2)
/LED3: R5.2, U1.21 (PB3)
/PB7: J3.2, U1.17 (PB7)
/PB23: J3.3, U1.25 (PB23)
/PROGD+: P2.A6 (D+), U1.15 (UD+)
/PROGD-: P2.A7 (D-), U1.16 (UD-)
/USBD+: P1.A6 (D+), U1.13 (U2D+)
/USBD-: P1.A7 (D-), U1.14 (U2D-)
/VDCIA: C1.2, C2.1, L1.2, U1.1 (VDCID), U1.35 (VDCIA)
/VSW: L1.1, U1.2 (VSW)
GND: C1.1, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, J2.2, J3.1, J4.1, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), P2.A1 (GND), P2.A12 (GND), P2.B1 (GND), P2.B12 (GND), P2.S1 (SHIELD), R1.2, R2.2, R3.2, R4.2, SW1.2, U1.0 (GND), U2.1 (GND), Y2.2, Y2.4
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R6.1
unnamed: D3.1 (K), R7.1
unnamed: J1.1, U1.39 (PA0/A9)
unnamed: J1.2, U1.40 (PA1/A8)
unnamed: J1.3, U1.41 (PA2/A7)
unnamed: J1.4, U1.42 (PA3/A6)
unnamed: J2.1, U1.34 (ANT)
unnamed: P1.A5 (CC), R1.1
unnamed: P1.B5 (VCONN), R2.1
unnamed: P2.A5 (CC), R3.1
unnamed: P2.B5 (VCONN), R4.1
unnamed: C3.2, U1.33 (VINTA)
unnamed: U1.47 (X32K0), Y1.1
unnamed: U1.48 (X32K1), Y1.2
unnamed: U1.32 (X32MI), Y2.1
unnamed: U1.31 (X32MO), Y2.3

## Commit log

2025-08-01 v1 layout finish
2025-08-04 opt ANT ground and M3 hole
2025-08-04 update ignore
2025-08-04 fix DCDC related value desc
2025-09-13 Scanner layout update
2025-09-13 add node t9e
2025-09-25 udpate readme
2025-09-25 fix README.md
2025-09-25 add DAS logos
